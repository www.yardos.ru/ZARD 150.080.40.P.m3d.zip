# KOMPAS-3D part (ZARD 150.080.40.P.m3d)

Model tree:
1. Операция без истории:1
